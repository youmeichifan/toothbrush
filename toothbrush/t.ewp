# IAR project t.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S103; DUTYCYLE1821
  ICCSTM8.CCIncludePath2: D:\doingPrj\toothbrush\sorftware\toothbrush\STM8S_StdPeriph_Driver\inc; D:\doingPrj\toothbrush\sorftware\toothbrush\user\inc
  ICCSTM8.IccLang: 0
  ASTM8.AsmIncludePath: D:\制作中项目\电动牙刷\软件\备份\tb\STM8S_StdPeriph_Driver\inc; D:\制作中项目\电动牙刷\软件\备份\tb\user\inc
  OBJCOPY.OOCOutputFile: t.hex
  ILINK.IlinkOutputFile: t.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  ICCSTM8.CCDefines: NDEBUG
  group library
    STM8S_StdPeriph_Driver/src/: stm8s_adc1.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_tim1.c stm8s_tim2.c
  group user
    user/src/: adc.c eeprom.c halt.c key.c main.c stm8s_it.c tim1.c tim2.c
